# Keil uVision project pio_interrupt.uvproj, settings and files
target AT91SAM7X256 (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: pio_interrupt +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group startup
    ./: SAM7.s
  group source
    ./: main.c
