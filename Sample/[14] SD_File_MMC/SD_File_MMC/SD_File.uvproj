# Keil uVision project SD_File.uvproj, settings and files
target AT91SAM7X (ARM-ADS)
  device: AT91SAM7XC256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: SD_File +hex
  c flags: Optim=4
  c include: ..\Library
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Source Files
    ./: Getline.c SD_File.c
  group Configuration Files
    ./: SAM7.s File_Config.c SPI_SAM7X.c
  group Com Port
    ./: Serial.c Retarget.c
  group Library
    C:/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
