# Keil uVision project ARMtest.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: ARMtest
  c flags: Optim=1
  c include: C:\Users\SC\Desktop
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Source Group 1
    ./: SAM7.s main.c
  group HTTP Files
    ../K1-Http/: Web.inp
